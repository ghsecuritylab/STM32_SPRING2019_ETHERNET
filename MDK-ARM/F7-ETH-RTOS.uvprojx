# Keil uVision project F7-ETH-RTOS.uvprojx, settings and files
target F7-ETH-RTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: F7-ETH-RTOS +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;  ../Middlewares/Third_Party/LwIP/src/include;  ../Middlewares/Third_Party/LwIP/system;  ../Drivers/STM32F7xx_HAL_Driver/Inc;  ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;  ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/LwIP/src/include/lwip;  ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;  ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;  ../Middlewares/Third_Party/LwIP/src/include/netif;  ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;  ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;  ../Middlewares/Third_Party/LwIP/src/include/posix;  ../Middlewares/Third_Party/LwIP/src/include/posix/sys;  ../Middlewares/Third_Party/LwIP/system/arch;  ../Drivers/CMSIS/Include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: main.c freertos.c lwip.c ethernetif.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_TIM.c tcpecho.c udpecho.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_eth.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
software components: CMSIS:CORE 4.3.0
